# IAR project sensorhub.ewp, settings and files
configuration iflash_lpcxpresso_54102 (ARM)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; BSX_LITE
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\bstlib\bsxlite\inc; ..\..\..\..\..\..\software\bstlib\sensors; ..\..\..\..\examples\sensorhub\bsx_lite; ..\..\..\..\examples\sensorhub\bsx_lite\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: sensorhub.bin
  ILINK.IlinkOutputFile: sh_bsx_lite.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\LPC5410x_sensorhub.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../startup/: iar_startup_lpc5410x.s sysinit.c
    ../../../../examples/sensorhub/bsx_lite/: kernel_res_mgr.c main.c kernel_wdt_timer.c hostif_i2c.c dma_routing.c hostif_spi.c hostif_cmd_hdlr.c sensacq_i2c.c sensors.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/iar_output/Exe/: board_lpcxpresso_54102.a
    ../../../../../../software/bstlib/: bosch_algo.c
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/iar_output/Exe/: chip_5410x_lib.a
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/power_lib/iar/: lib_power.a
    ../../../../../../software/bstlib/bsxlite/lib/arm_keil_iar/: libalgobsx.a
  group sensors
    ../../../../../../software/bstlib/sensors/: bma2x2.c bmi055.c bmi160.c bmm050.c bmp280.c max44000.c
