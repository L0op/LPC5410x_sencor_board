<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>iflash_lpcxpresso_54102</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>example</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\dma_routing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\heap_setup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\hostif_cmd_hdlr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\hostif_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\hostif_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\startup\iar_startup_lpc5410x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\kernel_res_mgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\kernel_rtos_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\power_mgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\sensacq_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\examples\sensorhub\freertos_bsxlite\sensors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\startup\sysinit.c</name>
    </file>
  </group>
  <group>
    <name>freertos</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertoslpc\FreeRTOSCommonHooks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\portable\MemMang\heap_3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\freertos\freertos\Source\timers.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102\iar_output\Exe\board_lpcxpresso_54102.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\bosch_algo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\iar_output\Exe\chip_5410x_lib.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\bsxlite\lib\arm_keil_iar\libalgobsx.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\power_lib\libpower.a</name>
    </file>
  </group>
  <group>
    <name>sensors</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\sensors\bma2x2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\sensors\bmi055.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\sensors\bmi160.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\sensors\bmm050.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\sensors\bmp280.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\software\bstlib\sensors\max44000.c</name>
    </file>
  </group>
</project>


