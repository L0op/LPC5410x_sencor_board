# IAR project freertos_bsxlite.ewp, settings and files
configuration iflash_lpcxpresso_54102 (ARM)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; BSX_LITE
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\bstlib\bsxlite\inc; ..\..\..\..\..\..\software\bstlib\sensors; ..\..\..\..\examples\sensorhub\freertos_bsxlite; ..\..\..\..\examples\sensorhub\freertos_bsxlite\config; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\examples\sensorhub\freertos_bsxlite\config
  OBJCOPY.OOCOutputFile: freertos_bsxlite.bin
  ILINK.IlinkOutputFile: sh_freertos_bsxlite.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\LPC5410x_heap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/sensorhub/freertos_bsxlite/: dma_routing.c heap_setup.c hostif_cmd_hdlr.c hostif_i2c.c hostif_spi.c kernel_res_mgr.c kernel_rtos_timer.c main.c power_mgr.c sensacq_i2c.c sensors.c
    ../../../../startup/: iar_startup_lpc5410x.s sysinit.c
  group freertos
    ../../../../../../software/freertos/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/iar_output/Exe/: board_lpcxpresso_54102.a
    ../../../../../../software/bstlib/: bosch_algo.c
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/iar_output/Exe/: chip_5410x_lib.a
    ../../../../../../software/bstlib/bsxlite/lib/arm_keil_iar/: libalgobsx.a
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/power_lib/iar/: lib_power.a
  group sensors
    ../../../../../../software/bstlib/sensors/: bma2x2.c bmi055.c bmi160.c bmm050.c bmp280.c max44000.c
