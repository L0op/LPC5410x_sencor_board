# Keil uVision project freertos_bsxlite.uvprojx, settings and files
target BSXLib (ARM-ADS)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sensorhub +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4 BSX_LITE M4CORE_MASTER
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410X;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410X\config;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102;..\..\..\..\..\..\software\bstlib\bsxlite\inc;..\..\..\..\..\..\software\bstlib\sensors;..\..\..\..\examples\sensorhub\freertos_bsxlite;..\..\..\..\examples\sensorhub\freertos_bsxlite\config;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F
  asm define: CORE_M4 BSX_LITE M4CORE_MASTER
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group example
    ../../../../startup/: sysinit.c
    ../../../../examples/sensorhub/freertos_bsxlite/: keil_startup_lpc5410x.s kernel_res_mgr.c main.c kernel_rtos_timer.c hostif_i2c.c dma_routing.c hostif_spi.c hostif_cmd_hdlr.c sensacq_i2c.c sensors.c heap_setup.c power_mgr.c
  group sensors
    ../../../../../../software/bstlib/sensors/: bma2x2.c bmm050.c bmp280.c max44000.c bmi160.c bmi055.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_5410X/keil_output/core_m4/: lib_chip_5410x.lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/keil_output/core_m4/: lib_board_lpcxpresso_lpc54102.lib
    ../../../../../../software/bstlib/bsxlite/lib/arm_keil_iar/: libalgobsx.lib
  group bstlib
    ../../../../../../software/bstlib/: bosch_algo.c
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
